# Keil uVision project HERO_C_Board.uvprojx, settings and files
target HERO_C_Board (6190000::V6.19::ARMCLANG)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: HERO_C_Board +hex
  c flags: Optim=5 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx,ARM_MATH_CM4,__TARGET_FPU_VFP,__CUSTOM_FILE_IO__
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../bsp;../bsp/can;../bsp/double_dma;../bsp/dwt;../bsp/gpio;../bsp/iic;../bsp/spi;../bsp/supervise;../bsp/usart;../bsp/usb;../application;../application/Chassis;../application/cmd;../application/Gimbal;../application/Referee;../application/Shoot;../Modules;../Modules/algorithm;../Modules/BMI088;../Modules/can_comm;../Modules/circular_queue;../Modules/controller;../Modules/imu;../Modules/ist8310;../Modules/motor;../Modules/motor/DJIMotor;../Modules/motor/DMmotor;../Modules/powermodules;../Modules/Referee_UI;../Modules/remote;../Modules/watch_dog;../RM_Lib/Inc/sys;../RM_Lib/Inc;../Drivers/CMSIS/DSP/Include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../bsp/buzzer;../application/Music;../bsp/pwm;../Modules/motor/servo_motor
  asm include: ../Inc;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: main.c gpio.c freertos.c can.c dma.c i2c.c rng.c rtc.c spi.c tim.c usart.c usb_device.c usbd_conf.c usbd_desc.c usbd_cdc_if.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
    ../Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group bsp
    ../bsp/can/: bsp_can.c
    ../bsp/double_dma/: DMA_double_buffer.c
    ../bsp/dwt/: bsp_dwt.c
    ../bsp/gpio/: bsp_gpio.c
    ../bsp/iic/: bsp_iic.c
    ../bsp/spi/: bsp_spi.c
    ../bsp/usart/: bsp_usart.c
    ../bsp/buzzer/: bsp_buzzer.c
    ../bsp/pwm/: bsp_pwm.c
    ../bsp/supervise/: bsp_supervise.c
    ../bsp/usb/: usb_typdef.h
    ../bsp/: bsp_def.h
  group cmd
    ../application/cmd/: Gimbal_board_cmd.c Chassis_board_cmd.c robot_def.h
  group Task
    ../application/: Task_Init.c Task_Vision.c Task_Protect.c Robot_Task.c
    ../Modules/imu/: ins_task.c
    ../application/Music/: Task_Music.c
  group IMU
    ../Modules/imu/: IMU.c BMI088driver.c BMI088reg.h BMI088Middleware.c
    ../Modules/ist8310/: ist8310.c
  group Modules
    ../Modules/can_comm/: can_comm.c
    ../Modules/circular_queue/: circular_queue.c cvector.c
    ../Modules/remote/: remote.c
    ../Modules/watch_dog/: WatchDog.c
    ../Modules/: pub_sub.c
    ../application/Music/: Music.c
  group algorithm
    ../Modules/algorithm/: kalman_filter.c adrc.c QuaternionEKF.c slope.c Matrix.c
    ../Modules/controller/: controller.c user_lib.c
  group power_controller
    ../Modules/powermodules/: RLS.c powercontroller.c SuperCAP.c
  group Gimbal
    ../application/Gimbal/: Gimbal.c Gimbal.h
  group Shoot
    ../application/Shoot/: Shoot.c Shoot.h
  group Referee
    ../application/Referee/: Referee.c
    ../Modules/Referee_UI/: Referee_unpack.c RM_Cilent_UI.c Referee_UI.c Referee_UI.h
  group Chassis
    ../application/Chassis/: Chassis.c Chassis.h
  group RM_Lib
    ../RM_Lib/Src/: VCOMCOMM.c RMQueue.c ramp.c PID.c motor.c CANDrive.c CRC.c
  group MOTOR
    ../Modules/motor/DJIMotor/: DJIMotor.c
    ../Modules/motor/DMmotor/: DMmotor.c
    ../Modules/motor/: motor_def.c
    ../Modules/motor/servo_motor/: servo_motor.c servo_motor.h
  group USB
    ../bsp/usb/: attribute_typedef.h struct_typedef.h usb_debug.h usb_task.c usb_typdef.h usb_task.h
software components: CMSIS:CORE 5.6.0
